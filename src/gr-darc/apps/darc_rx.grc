<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>darc_rx</value></param>
<param><key>author</key><value>andz, chris007 (Chaos Computer Club Munich)</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>FM Receiver and DARC Decoder</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_decim</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_decim_rate</value></param>
<param><key>value</key><value>int(baseband_rate/audio_decim)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>audio_volume</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Audio Volume</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baseband_rate</value></param>
<param><key>value</key><value>samp_rate/bb_decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bb_decim</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>darc_bits</value></param>
<param><key>value</key><value>16e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>darc_decim</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>darc_gain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>DARC Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>darc_offset</value></param>
<param><key>value</key><value>76e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>darc_trans</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>darc_transition</value></param>
<param><key>value</key><value>darc_width * darc_trans</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>darc_width</value></param>
<param><key>value</key><value>8e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>90e6</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>87.5e6</value></param>
<param><key>step</key><value>1e5</value></param>
<param><key>stop</key><value>108e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_tune</value></param>
<param><key>value</key><value>freq-freq_offset</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>recfile</value></param>
<param><key>value</key><value>"/home/andz/workspace/git/darc/dumps/b5_akt_" + datetime.now().strftime("%Y%m%d_%H%M") + ".gnuradio"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>24</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1024e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>volume</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>label</key><value>Baseband Volume</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_bandwidth</value></param>
<param><key>value</key><value>120000</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>DARC_Tabs</value></param>
<param><key>label0</key><value>Baseband Waterfall</value></param>
<param><key>label1</key><value>Baseband FFT</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>bb_decim</value></param>
<param><key>quad_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>recfile</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/andz/desktop/testfile.gnuradio</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>recfile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>darc_gain</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>volume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0</value></param>
<param><key>const</key><value>audio_volume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>51337</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>psize</key><value>24</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>24</value></param>
</block>
<block>
<key>darc_layer2</key>
<param><key>id</key><value>darc_layer2_1</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>errorwidth</key><value>8</value></param>
<param><key>log</key><value>True</value></param>
<param><key>repair</key><value>True</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>digital_gmsk_demod_0</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>1</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>samples_per_symbol</key><value>int(baseband_rate/darc_bits)/darc_decim</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_1</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1.0,baseband_rate,13e3,3e3,firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>freq_offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, xlate_bandwidth, xlate_bandwidth*darc_trans)</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_2</value></param>
<param><key>center_freq</key><value>darc_offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/bb_decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1,baseband_rate,darc_width,darc_transition,firdes.WIN_BLACKMAN,6.76)</value></param>
<param><key>type</key><value>fcf</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>DARC_Layer1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>Center DARC Frequency (76kHz) and LPF it</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>note</key><value>Demodulate MSK</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0_0</value></param>
<param><key>note</key><value>Send DARC bits via UDP</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Write Layer 1 output to file</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Record IQ</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1</value></param>
<param><key>note</key><value>Audio Path</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_3</value></param>
<param><key>note</key><value>DARC_Layer2</value></param>
</block>
<block>
<key>pluto_source</key>
<param><key>id</key><value>pluto_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>uri</key><value>192.168.2.1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>gain</key><value>"manual"</value></param>
<param><key>frequency</key><value>int(freq_tune)</value></param>
<param><key>manual_gain</key><value>rx_gain</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>bandwidth</key><value>20000000</value></param>
<param><key>samplerate</key><value>int(samp_rate)</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>baseband_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>DARC_Tabs@1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Baseband</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1_0</value></param>
<param><key>axislabels</key><value>False</value></param>
<param><key>bw</key><value>baseband_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>DARC_Tabs@0</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>int_min</key><value>-100</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler</value></param>
<param><key>decim</key><value>audio_decim_rate</value></param>
<param><key>interp</key><value>audio_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>darc_decim</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq-freq_offset</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_1</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq_tune</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_1</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>digital_gmsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>darc_layer2_1</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_demod_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_demod_0</source_block_id><sink_block_id>darc_layer2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_1</source_block_id><sink_block_id>rational_resampler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_2</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
